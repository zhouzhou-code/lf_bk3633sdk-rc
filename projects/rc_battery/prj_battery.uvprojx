# Keil uVision project prj_battery.uvprojx, settings and files
target Target1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: rc_battery
  AfterMake: fromelf --bin --output .\output\app\rc_battery.bin .\obj\rc_battery.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: CFG_CPU_BK3633
  c misc: --gnu
  c include: ..\..\src\ip\ble\ll\api;..\..\src\ip\ble\ll\import\reg;..\..\src\ip\ble\ll\src;..\..\src\ip\bt\api;..\..\src\ip\bt\import\reg;..\..\src\ip\bt\src;..\..\src\ip\em\api;..\..\src\ip\hci\api;..\..\src\ip\sch\api;..\..\src\ip\sch\import;..\..\src\modules\aes\api;..\..\src\modules\common\api;..\..\src\modules\dbg\api;..\..\src\modules\ecc_p256\api;..\..\src\modules\h4tl\api;..\..\src\modules\ke\api;..\..\src\plf\nvds\api;..\..\src\driver\rf;..\..\src\plf\rwip\api;..\..\src\plf\rwip\import\reg;..\..\src\plf\refip\import\reg;..\..\src\plf\refip\src\arch;..\..\src\plf\refip\src\arch\boot\rvds;..\..\src\plf\refip\src\arch\compiler\rvds;..\..\src\plf\refip\src\arch\ll\rvds;..\..\src\driver\flash;..\..\src\driver\led;..\..\src\driver\reg;..\..\src\driver\syscntl;..\..\src\driver\timer;..\..\Src\header;..\..\Src\header\header_file;..\..\Src\plf\refip\src\driver;..\..\Src\ip\ble\hl\api;..\..\Src\ip\ble\hl\inc;..\..\Src\ip\ble\hl\src\gap\gapc;..\..\Src\ip\ble\hl\src\gap\gapm;..\..\Src\ip\ble\hl\src\gatt;..\..\Src\ip\ble\hl\src\gatt\attc;..\..\Src\ip\ble\hl\src\gatt\attm;..\..\Src\ip\ble\hl\src\gatt\atts;..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\Src\app\api;..\..\Src\profiles\dis\diss\api;..\..\Src\profiles\FEE0\api;..\..\Src\profiles\bas\bass\api;..\..\Src\profiles\FCC0_128\api;..\..\Src\driver\spi;..\..\Src\driver\icu;..\..\Src\driver\wdt;..\..\Src\driver\adc;..\..\Src\profiles\ancs\ancsc\api;..\..\Src\profiles\oad\api;..\..\Src\profiles\ancs\ancsc;.\system;..\rc_remote\drivers\rf;..\rc_remote\drivers\gpio;..\rc_remote\drivers\uart;..\rc_remote\drivers\common;..\rc_remote\middleware\rf_handler;..\rc_remote\middleware\rf_service;..\rc_remote\middleware\timer;..\rc_remote\middleware\protocol;.\app;..\rc_remote\devices\hall;..\rc_remote\devices\key;..\rc_remote\devices\oled;..\rc_remote\test;..\..\src\driver\uart2;..\..\src\driver\aon_rtc;..\..\src\plf\prf;..\..\Src\driver\intc;..\..\src\driver\dma;..\..\src\driver\i2c;..\..\src\device\lcd;..\..\src\device\spi_flash;..\..\src\driver\usb;..\..\src\driver\usb\include;..\..\src\driver\usb\include\class;..\..\src\driver\usb\src\cd;..\..\src\driver\usb\src\drivers\comm;..\..\src\driver\usb\src\drivers\msd;..\..\src\driver\usb\src\examples;..\..\src\driver\usb\src\functions\trans_fn;..\..\src\driver\usb\src\systems\none;..\..\src\driver\usb\src\systems\none\afs;..\..\src\driver\usb\src\test;..\..\src\driver\usb\src\test\msd;..\rc_remote\drivers\rf;..\..\src\driver\sensor;..\..\src\driver\timer;..\..\src\driver\flash;..\..\src\driver\usb_driver;..\..\src\driver\usb_driver\usb;..\rc_remote\drivers\common\debug;..\rc_remote\drivers\common\queue;..\rc_remote\devices\battery
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\app_24_link.txt
  link misc: --entry sys_Reset
  group system
    ./system/: handlers.s vectors.s user_config.h
    ./app/: main.c intc.c
  group Application
    ./app/: app_bat_passthrough.c app_bat_passthrough.h bat_protocol.c bat_protocol.h
  group Middleware/rf_service
    ../rc_remote/middleware/rf_service/: rf_pair.c addr_pool.c rf_config.c
    ../rc_remote/middleware/protocol/: rc_protocol.c
  group Middleware/handlers
    ../rc_remote/middleware/rf_handler/: rf_handler.c
    ../rc_remote/middleware/timer/: timer_handler.c
  group Drivers/common
    ../rc_remote/drivers/common/: my_queue.c debug.c
  group Drivers/custom
    ../rc_remote/drivers/uart/: my_drv_uart.c my_drv_uart2.c
    ../rc_remote/drivers/gpio/: drv_gpio.c
    ../rc_remote/drivers/rf/: hal_drv_rf.c
  group SDK/Peripherals_Driver
    ../../Src/driver/flash/: flash.c
    ../../Src/driver/rf/: rf_xvr_24.c
    ../../Src/driver/spi/: spi.c
    ../../Src/driver/icu/: icu.c
    ../../Src/driver/wdt/: wdt.c
    ../../Src/driver/adc/: adc.c
    ../../src/driver/aon_rtc/: aon_rtc.c
    ../../src/driver/i2c/: i2c.c
    ../../src/driver/dma/: dma.c
    ../../src/driver/timer/: driver_timer.c
  group SDK/usb_Driver
    ../../src/driver/usb_driver/: driver_usb.c
    ../../src/driver/usb_driver/usb/: usb.c usb_desc.c usbclass.c
