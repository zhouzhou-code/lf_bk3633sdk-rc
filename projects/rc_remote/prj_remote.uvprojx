# Keil uVision project prj_remote.uvprojx, settings and files
target Target1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: rc_remote
  AfterMake: fromelf --bin --output .\output\app\rc_remote.bin .\obj\rc_remote.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: CFG_CPU_BK3633
  c misc: --gnu
  c include: ..\..\src\ip\ble\ll\api;..\..\src\ip\ble\ll\import\reg;..\..\src\ip\ble\ll\src;..\..\src\ip\bt\api;..\..\src\ip\bt\import\reg;..\..\src\ip\bt\src;..\..\src\ip\em\api;..\..\src\ip\hci\api;..\..\src\ip\sch\api;..\..\src\ip\sch\import;..\..\src\modules\aes\api;..\..\src\modules\common\api;..\..\src\modules\dbg\api;..\..\src\modules\ecc_p256\api;..\..\src\modules\h4tl\api;..\..\src\modules\ke\api;..\..\src\plf\nvds\api;..\..\src\driver\rf;..\..\src\plf\rwip\api;..\..\src\plf\rwip\import\reg;..\..\src\plf\refip\import\reg;..\..\src\plf\refip\src\arch;..\..\src\plf\refip\src\arch\boot\rvds;..\..\src\plf\refip\src\arch\compiler\rvds;..\..\src\plf\refip\src\arch\ll\rvds;..\..\src\driver\flash;..\..\src\driver\led;..\..\src\driver\reg;..\..\src\driver\syscntl;..\..\src\driver\timer;..\..\Src\header;..\..\Src\header\header_file;..\..\Src\plf\refip\src\driver;..\..\Src\ip\ble\hl\api;..\..\Src\ip\ble\hl\inc;..\..\Src\ip\ble\hl\src\gap\gapc;..\..\Src\ip\ble\hl\src\gap\gapm;..\..\Src\ip\ble\hl\src\gatt;..\..\Src\ip\ble\hl\src\gatt\attc;..\..\Src\ip\ble\hl\src\gatt\attm;..\..\Src\ip\ble\hl\src\gatt\atts;..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\Src\app\api;..\..\Src\profiles\dis\diss\api;..\..\Src\profiles\FEE0\api;..\..\Src\profiles\bas\bass\api;..\..\Src\profiles\FCC0_128\api;..\..\Src\driver\spi;..\..\Src\driver\icu;..\..\Src\driver\wdt;..\..\Src\driver\adc;..\..\Src\profiles\ancs\ancsc\api;..\..\Src\profiles\oad\api;..\..\Src\profiles\ancs\ancsc;.\system;.\drivers\rf;.\drivers\gpio;.\drivers\uart;.\drivers\common;.\middleware\rf_handler;.\middleware\rf_service;.\middleware\timer;.\middleware\protocol;.\app;.\devices\hall;.\devices\key;.\devices\oled;.\test;..\..\src\driver\uart2;..\..\src\driver\aon_rtc;..\..\src\plf\prf;..\..\Src\driver\intc;..\..\src\driver\dma;..\..\src\driver\i2c;..\..\src\device\lcd;..\..\src\device\spi_flash;..\..\src\driver\usb;..\..\src\driver\usb\include;..\..\src\driver\usb\include\class;..\..\src\driver\usb\src\cd;..\..\src\driver\usb\src\drivers\comm;..\..\src\driver\usb\src\drivers\msd;..\..\src\driver\usb\src\examples;..\..\src\driver\usb\src\functions\trans_fn;..\..\src\driver\usb\src\systems\none;..\..\src\driver\usb\src\systems\none\afs;..\..\src\driver\usb\src\test;..\..\src\driver\usb\src\test\msd;.\drivers\rf;..\..\src\driver\sensor;..\..\src\driver\timer;..\..\src\driver\flash;..\..\src\driver\usb_driver;..\..\src\driver\usb_driver\usb;.\drivers\common\debug;.\drivers\common\queue;.\devices\battery
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\src\system\app_24_link.txt
  link misc: --entry sys_Reset
  group system
    ./system/: handlers.s vectors.s user_config.h
    ./app/: main.c intc.c
  group Application
    ./app/: pinmap.h rc_scheduler.c rc_scheduler.h app_sleep.c app_sleep.h app_key.c app_key.h app_throttle.c app_throttle.h
    ./middleware/protocol/: rc_protocol.c rc_protocol.h
    ./test/: test_slave.c test_bat_slave.c
  group Devices
    ./devices/hall/: hall_sensor.c hall_sensor.h HALL_API_REFERENCE.md
    ./devices/key/: key_scan.c key_scan.h
    ./devices/battery/: bat_manage.c bat_manage.h
  group Middleware/rf_service
    ./middleware/rf_service/: rf_pair.c rf_pair.h addr_pool.c addr_pool.h rf_config.c rf_config.h
    ./middleware/protocol/: rc_protocol.md
  group Middleware/handlers
    ./middleware/rf_handler/: rf_handler.c rf_handler.h
    ./middleware/timer/: timer_handler.c timer_handler.h
  group Drivers/common
    ./drivers/common/: my_queue.c my_queue.h debug.c debug.h
  group SDK/Core/Peripherals_Driver
    ./drivers/uart/: my_drv_uart.c my_drv_uart2.c my_drv_uart.h
    ./drivers/gpio/: drv_gpio.c drv_gpio.h
    ./drivers/rf/: hal_drv_rf.c
    ../../Src/driver/flash/: flash.c
    ../../Src/driver/rf/: rf_xvr_24.c
    ../../Src/driver/spi/: spi.c
    ../../Src/driver/icu/: icu.c
    ../../Src/driver/wdt/: wdt.c
    ../../Src/driver/adc/: adc.c
    ../../src/driver/aon_rtc/: aon_rtc.c
    ../../src/driver/i2c/: i2c.c
    ../../src/driver/dma/: dma.c
    ../../src/driver/timer/: driver_timer.c
  group SDK/Core/usb_Driver
    ../../src/driver/usb_driver/: driver_usb.c
    ../../src/driver/usb_driver/usb/: usb.c usb_desc.c usbclass.c
