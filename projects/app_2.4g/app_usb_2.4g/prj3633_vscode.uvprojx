# Keil uVision project prj3633_vscode.uvprojx, settings and files
target Target1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_app
  AfterMake: fromelf --bin --output .\output\app\bk3633_app.bin .\obj\bk3633_app.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: CFG_CPU_BK3633
  c misc: --gnu
  c include: ..\..\..\src\ip\ble\ll\api;..\..\..\src\ip\ble\ll\import\reg;..\..\..\src\ip\ble\ll\src;..\..\..\src\ip\bt\api;..\..\..\src\ip\bt\import\reg;..\..\..\src\ip\bt\src;..\..\..\src\ip\em\api;..\..\..\src\ip\hci\api;..\..\..\src\ip\sch\api;..\..\..\src\ip\sch\import;..\..\..\src\modules\aes\api;..\..\..\src\modules\common\api;..\..\..\src\modules\dbg\api;..\..\..\src\modules\ecc_p256\api;..\..\..\src\modules\h4tl\api;..\..\..\src\modules\ke\api;..\..\..\src\plf\nvds\api;..\..\..\src\driver\rf;..\..\..\src\plf\rwip\api;..\..\..\src\plf\rwip\import\reg;..\..\..\src\plf\refip\import\reg;..\..\..\src\plf\refip\src\arch;..\..\..\src\plf\refip\src\arch\boot\rvds;..\..\..\src\plf\refip\src\arch\compiler\rvds;..\..\..\src\plf\refip\src\arch\ll\rvds;..\..\..\src\driver\flash;..\..\..\src\driver\led;..\..\..\src\driver\reg;..\..\..\src\driver\syscntl;..\..\..\src\driver\timer;..\..\..\Src\header;..\..\..\Src\header\header_file;..\..\..\Src\plf\refip\src\driver;..\..\..\Src\ip\ble\hl\api;..\..\..\Src\ip\ble\hl\inc;..\..\..\Src\ip\ble\hl\src\gap\gapc;..\..\..\Src\ip\ble\hl\src\gap\gapm;..\..\..\Src\ip\ble\hl\src\gatt;..\..\..\Src\ip\ble\hl\src\gatt\attc;..\..\..\Src\ip\ble\hl\src\gatt\attm;..\..\..\Src\ip\ble\hl\src\gatt\atts;..\..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\..\Src\app\api;..\..\..\Src\profiles\dis\diss\api;..\..\..\Src\profiles\FEE0\api;..\..\..\Src\profiles\bas\bass\api;..\..\..\Src\profiles\FCC0_128\api;..\..\..\Src\driver\spi;..\..\..\Src\driver\icu;..\..\..\Src\driver\wdt;..\..\..\Src\driver\adc;..\..\..\Src\profiles\ancs\ancsc\api;..\..\..\Src\profiles\oad\api;..\..\..\Src\profiles\ancs\ancsc;.\system;.\app\api;..\..\..\src\driver\uart2;..\..\..\src\driver\aon_rtc;..\..\..\src\plf\prf;..\..\..\Src\driver\intc;..\..\..\src\driver\dma;..\..\..\src\driver\i2c;..\..\..\src\device\lcd;..\..\..\src\device\spi_flash;..\..\..\src\driver\usb;..\..\..\src\driver\usb\include;..\..\..\src\driver\usb\include\class;..\..\..\src\driver\usb\src\cd;..\..\..\src\driver\usb\src\drivers\comm;..\..\..\src\driver\usb\src\drivers\msd;..\..\..\src\driver\usb\src\examples;..\..\..\src\driver\usb\src\functions\trans_fn;..\..\..\src\driver\usb\src\systems\none;..\..\..\src\driver\usb\src\systems\none\afs;..\..\..\src\driver\usb\src\test;..\..\..\src\driver\usb\src\test\msd;.\app\src\2.4;..\..\..\src\driver\sensor;..\..\..\src\driver\timer;..\..\..\src\driver\flash;..\..\..\src\driver\usb_driver;..\..\..\src\driver\usb_driver\usb;.\driver_restruct\common;.\driver_restruct\common\debug;.\driver_restruct\common\queue;.\driver_restruct\Driver_RF;.\driver_restruct\Driver_GPIO;.\driver_restruct\Driver_Uart;.\driver_restruct\Driver_Uart2;.\Handler\RF_Handler;.\Handler\Timer_Handler;.\app\src\bat_transmit;.\app\src\rf_service;.\app\src\remote_control;.\app\src\remote_control\app;.\app\src\remote_control\device\hall;.\app\src\remote_control\device\key;.\driver_restruct\Driver_GPIO;.\app\src\remote_control\device\oled
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\..\src\system\app_24_link.txt
  link misc: --entry sys_Reset
  group system
    ./system/: handlers.s vectors.s user_config.h
    ./app/src/: main.c intc.c
  group Application/remote_control/app
    ./app/src/remote_control/app/: rc_scheduler.c rc_scheduler.h app_sleep.c app_sleep.h app_shutdown.c app_shutdown.h app_key.c app_key.h app_throttle.c app_throttle.h rc_protocol.c rc_protocol.h test_slave.c
  group Application/remote_control/device
    ./app/src/remote_control/device/hall/: hall_sensor.c hall_sensor_example.c hall_sensor.h API_REFERENCE.md
    ./app/src/remote_control/device/key/: key_scan.c key_scan.h
    ./app/src/remote_control/device/oled/: lcd_init.c lcd_init.h lcd_kmg.c lcd_kmg.h LCD_SPI_CS_TIMING_FIX.md
  group Application/remote_control/config
    ./app/src/remote_control/: pinmap_v1.h
  group Application/battary_tramsmit
    ./app/src/bat_transmit/: bat_protocol.c bat_protocol.h
  group Application/rf_service
    ./app/src/rf_service/: rf_addr_mgr.c rf_addr_mgr.h rf_pair.c rf_pair.h addr_pool.c addr_pool.h rf_protocol.c rf_protocol.h
  group Application/Example/mouse
    ./app/src/: app.c aes.c
  group Application/Example/rf
    ./app/src/2.4/: application_main.c APPLICATION_MODE_NORMAL.c application_mode_page.c application_mode_PCBA.c APPLICATION_MODE_TEST.C application_rf.c driver_rf.c test_my_rf_fun.c
  group Middleware/handlers
    ./Handler/RF_Handler/: rf_handler.c rf_handler.h
    ./Handler/Timer_Handler/: timer_handler.c timer_handler.h
  group Middleware/Driver/Common
    ./driver_restruct/common/queue/: my_queue.c my_queue.h
    ./driver_restruct/common/debug/: debug.c debug.h
  group SDK/Driver/Peripherals_Driver
    ../../../Src/driver/flash/: flash.c
    ../../../Src/driver/rf/: rf_xvr_24.c
    ../../../Src/driver/gpio/: gpio.c
    ../../../Src/driver/spi/: spi.c
    ../../../Src/driver/icu/: icu.c
    ../../../Src/driver/wdt/: wdt.c
    ../../../Src/driver/adc/: adc.c
    ../../../Src/driver/uart2/: uart2.c
    ../../../src/driver/uart/: uart.c
    ../../../src/driver/aon_rtc/: aon_rtc.c
    ../../../src/driver/i2c/: i2c.c
    ../../../src/driver/dma/: dma.c
    ../../../src/driver/timer/: driver_timer.c
    ../../../src/driver/sensor/: driver_sensor.c
    ./driver_restruct/Driver_RF/: hal_drv_rf.c
    ./driver_restruct/Driver_Uart2/: my_drv_uart2.c
    ./driver_restruct/Driver_GPIO/: drv_gpio.c drv_gpio.h
    ./driver_restruct/Driver_Uart/: my_drv_uart.c my_drv_uart.h
  group SDK/Driver/usb_Driver
    ../../../src/driver/usb_driver/: driver_usb.c
    ../../../src/driver/usb_driver/usb/: usb.c usb_desc.c usbclass.c
